# IAR project Backup (2) of ST87_G071_SL.ewp, settings and files
configuration ST87_G071_SL (ARM, debug)
  General.OGChipSelectEditMenu: STM32G071GB ST STM32G071GB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; CMSIS_device_header=<stm32g0xx.h>; USE_HAL_DRIVER; STM32G071xx; STM32G0; PCB_1_2; PCB_1_0NO; CES25NO; LIS2DUX12; LIS2DU12NO; LIS2DW12NO; COMM_DEBUG
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; ../Drivers\BSP\cloud\inc; ../Drivers\BSP\Components\lis2du12; ../Drivers\BSP\Components\lis2dux12; ../Drivers\BSP\Components\lis2dw12; ../Libs/m2m_modem/inc; ../Libs/inc; ../Apps/Cloud/inc; ../Apps/Metrology/inc; ../Apps/Sensor/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include
  OBJCOPY.OOCOutputFile: ST87_G071_SL.hex
  ILINK.IlinkOutputFile: ST87_G071_SL.out
  ILINK.IlinkIcfFile: stm32g071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g071xx.s
  group Application/User/Apps
    ../Apps/Cloud/src/: cloud_module.c m2m_modem.c
    ../Core/Src/: crc.c mem_pool.c task_comm.c
    ../Apps/metrology/src/: metro_hif.c metrology_module.c
    ../Apps/Sensor/src/: Sensor_module.c
  group Application/User/Core
    ../Core/Src/: app_freertos.c main.c stm32g0xx_hal_msp.c stm32g0xx_hal_timebase_tim.c stm32g0xx_it.c
  group Drivers/BSP
    ../Drivers/BSP/Components/lis2du12/: lis2du12_reg.c
    ../Drivers/BSP/Components/lis2dux12/: lis2dux12_reg.c
    ../Drivers/BSP/Components/lis2dw12/: lis2dw12_reg.c
    ../Drivers/BSP/cloud/src/: stm32_st87m01.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_rcc.c stm32g0xx_ll_utils.c
  group Libs
    ../Libs/src/: utilities.c
  group Libs/m2m_modem
    ../Libs/m2m_modem/src/: app_modem_read.c modem_event_buffer.c modem_globals.c modem_interface.c modem_main.c modem_module.c modem_ring_buffer.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
